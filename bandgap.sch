** sch_path: bandgap.sch
**.subckt bandgap
Xpfet1 net1 v2 vdd vdd asap_7nm_pfet l=7n nfin=14
Xpfet2 net5 v2 net1 vdd asap_7nm_pfet l=7n nfin=14
Xpfet3 net6 net5 v2 vdd asap_7nm_pfet l=7n nfin=28
Xnfet1 v5 v5 net2 GND asap_7nm_nfet l=7n nfin=1
Xnfet2 net2 net2 GND GND asap_7nm_nfet l=7n nfin=1
Xpfet4 v1 v2 vdd vdd asap_7nm_pfet l=7n nfin=14
Xpfet7 v2 v2 vdd vdd asap_7nm_pfet l=7n nfin=14
[
if {[sim_is_ngspice]} {
return {R1 net4 v4 33k noisy=1 m=1 }
} else {
return {R1 net4 v4 33k m=1 }
}
]
Xpfet8 Vref v2 vdd vdd asap_7nm_pfet l=7n nfin=14
[
if {[sim_is_ngspice]} {
return {R2 Vref Vctat 50k noisy=1 m=1 }
} else {
return {R2 Vref Vctat 50k m=1 }
}
]
Xnfet8 Vctat Vctat GND GND asap_7nm_nfet l=7n nfin=14
Xnfet9 net7 v1 net4 GND asap_7nm_nfet l=7n nfin=48
Xnfet10 v1 v1 net3 GND asap_7nm_nfet l=7n nfin=48
V3 net5 v5 0
V4 net3 v3 0
V5 v2 net7 0
V7 net6 v1 0
Xnfet3 v3 v3 GND GND asap_7nm_nfet l=7n nfin=16
Xnfet4 v4 v4 GND GND asap_7nm_nfet l=7n nfin=16
Xnfet5 v4 v4 GND GND asap_7nm_nfet l=7n nfin=16
Xnfet6 v4 v4 GND GND asap_7nm_nfet l=7n nfin=16
Xnfet7 v4 v4 GND GND asap_7nm_nfet l=7n nfin=16
Xnfet11 vdn vgn GND GND asap_7nm_nfet l=7n nfin=1
VGn vgn GND {vgs}
VDn vdn GND {vds}
Xpfet5 vdp vgp VDD VDD asap_7nm_pfet l=7n nfin=14
VDn1 VDD vdp {vds}
VGn1 VDD vgp {vgs}
.IC V(net8)=0.35
[
if {[sim_is_ngspice]} {
return {R3 net8 GND 33k noisy=1 m=1 }
} else {
return {R3 net8 GND 33k m=1 }
}
]
C1 net8 GND 1n m=1
C2 vdd v2 1p m=1
V2 vdd_dc GND {VDD}
V1 vdd GND pulse(0 {VDD} 20p 100p 100p 200n 500n 1)
**** begin user architecture code



.param vds = 0.7
.param vgs = 0.1

.param VDD = 0.8

*.temp -40 0 40 80 120
*.dc VDn 0 2 10m  VGn 0.0 0.7 0.05

.dc temp -40 120 10
*.tran 10p 10n

.control
    pre_osdi $ASAP7_OSDI
.endc
.control
    *alter V1 value={VDD}
    dc temp -40 120 10
    plot Vref Vctat
    let vconst_slope_vs_temp = deriv(V(vctat))
    let vref_slope_vs_temp = deriv(V(vref))
    meas dc vconst find V(vctat) at=25
    meas dc vref25 find V(vref)  at=25
    meas dc vconst_slope find vconst_slope_vs_temp at=25
    meas dc vref25_slope find vref_slope_vs_temp  at=25
.endc

.control
    *run
    *temp -40 0 40 80 120
    tran 100p 100n
    meas tran vref_final find V(vref) at=1n
    let vtarget = vref_final * 0.99   ; 1% deviation
    meas tran tstart find time when V(vref)=vtarget
    let tstart = tstart - 120p    ; end of supply rise
    set xbrushwidth=3
    plot Vref Vctat vdd
.endc

.control
    * fet characteristics
    alter VDn 0.7
    dc VGn 0 0.7 1m
    let id = -i(VDn)
    *plot -i(VDn)
    meas dc Vth_sat when id = 100n from = 0 to = 0.7

    alter VDn 0.05
    dc VGn 0 0.7 1m
    let id = -i(VDn)
    *plot -i(VDn)
    meas dc Vth_lin when id = 100n from = 0 to = 0.7

    dc VDn 0 2 10m  VGn 0.0 0.7 0.05
    set xbrushwidth=3
    *plot -i(VDn)
.endc




**** end user architecture code
**.ends
.GLOBAL GND
**** begin user architecture code

.subckt asap_7nm_nfet S G D B l=@l nfin=@nfin
	nnmos_finfet S G D B BSIMCMG_osdi_N l=@l nfin=@nfin
.ends asap_7nm_nfet

.model BSIMCMG_osdi_N BSIMCMG_va (  TYPE = 1
************************************************************
*                         general                          *
************************************************************ version = 107             bulkmod = 1
*+               igcmod  = 1               igbmod  = 0              gidlmod = 1               iimod   = 0
*+               geomod  = 1               rdsmod  = 0              rgatemod= 0               rgeomod = 0
*+               shmod   = 0               nqsmod  = 0              coremod = 0               cgeomod = 0
*+               capmod  = 0               tnom    = 25             eot     = 1e-009          eotbox  = 1.4e-007
*+        eotacc  = 1e-010          tfin    = 6.5e-009       toxp    = 2.1e-009        nbody   = 1e+022
*+          phig    = 4.2466          epsrox  = 3.9            epsrsub = 11.9            easub   = 4.05
*+            ni0sub  = 1.1e+016        bg0sub  = 1.17           nc0sub  = 2.86e+025       nsd     = 2e+026
*+          ngate   = 0               nseg    = 5              l       = 2.1e-008        xl      = 1e-009
*+          lint    = -2e-009         dlc     = 0              dlbin   = 0               hfin    = 3.2e-008
*+        deltaw  = 0               deltawcv= 0              sdterm  = 0               epsrsp  = 3.9
*+             nfin    = 1 toxg    = 1.80e-009
************************************************************
*                            dc                            *
************************************************************ cit     = 0               cdsc    =
*+ 0.01            cdscd   = 0.01            dvt0    = 0.05           dvt1    = 0.47            phin    =
*+ 0.05            eta0    = 0.07            dsub    = 0.35           k1rsce  = 0               lpe0    = 0
*+               dvtshift= 0               qmfactor= 2.5            etaqm   = 0.54            qm0     = 0.001           pqm
*+     = 0.66            u0      = 0.0303         etamob  = 2               up      = 0               ua
*+      = 0.55            eu      = 1.2            ud      = 0               ucs     = 1
*+               rdswmin = 0               rdsw    = 200            wr      = 1               rswmin  = 0
*+               rdwmin  = 0               rshs    = 0              rshd    = 0               vsat    = 70000
*+           deltavsat= 0.2             ksativ  = 2              mexp    = 4               ptwg    = 30              pclm
*+    = 0.05            pclmg   = 0              pdibl1  = 0               pdibl2  = 0.002           drout
*+   = 1               pvag    = 0              fpitch  = 2.7e-008        rth0    = 0.225           cth0
*+    = 1.243e-006      wth0    = 2.6e-007       lcdscd  = 5e-005          lcdscdr = 5e-005          lrdsw
*+   = 0.2             lvsat   = 0
************************************************************
*                         leakage                          *
************************************************************ aigc    = 0.014           bigc    =
*+ 0.005           cigc    = 0.25            dlcigs  = 1e-009         dlcigd  = 1e-009          aigs    =
*+ 0.0115          aigd    = 0.0115          bigs    = 0.00332        bigd    = 0.00332         cigs    =
*+ 0.35            cigd    = 0.35            poxedge = 1.1            agidl   = 1e-012          agisl   =
*+ 1e-012          bgidl   = 10000000        bgisl   = 10000000       egidl   = 0.35            egisl   =
*+ 0.35
************************************************************
*                            rf                            *
************************************************************
************************************************************
*                         junction                         *
************************************************************
************************************************************
*                       capacitance                        *
************************************************************ cfs     = 0               cfd     = 0
*+               cgso    = 1.6e-010        cgdo    = 1.6e-010       cgsl    = 0               cgdl    = 0
*+               ckappas = 0.6             ckappad = 0.6            cgbo    = 0               cgbl    = 0
************************************************************
*                       temperature                        *
************************************************************ tbgasub = 0.000473        tbgbsub = 636
*+             kt1     = 0               kt1l    = 0              ute     = -0.7            utl     = 0
*+               ua1     = 0.001032        ud1     = 0              ucste   = -0.004775       at      = 0.001
*+           ptwgt   = 0.004           tmexp   = 0              prt     = 0               tgidl   = -0.007
*+          igt     = 2.5
************************************************************
*                          noise                           *
************************************************************
**)
.control
pre_osdi /home/vsduser/Documents/asap_7nm_Xschem/bsimcmg.osdi
.endc



.subckt asap_7nm_pfet S G D B l=@l nfin=@nfin
	npmos_finfet S G D B BSIMCMG_osdi_P l=@l nfin=@nfin
.ends asap_7nm_pfet

.model BSIMCMG_osdi_P BSIMCMG_va (  TYPE = 0

************************************************************
*                         general                          *
************************************************************ version = 107             bulkmod = 1
*+               igcmod  = 1               igbmod  = 0              gidlmod = 1               iimod   = 0
*+               geomod  = 1               rdsmod  = 0              rgatemod= 0               rgeomod = 0
*+               shmod   = 0               nqsmod  = 0              coremod = 0               cgeomod = 0
*+               capmod  = 0               tnom    = 25             eot     = 1e-009          eotbox  = 1.4e-007
*+        eotacc  = 3e-010          tfin    = 6.5e-009       toxp    = 2.1e-009        nbody   = 1e+022
*+          phig    = 4.9278          epsrox  = 3.9            epsrsub = 11.9            easub   = 4.05
*+            ni0sub  = 1.1e+016        bg0sub  = 1.17           nc0sub  = 2.86e+025       nsd     = 2e+026
*+          ngate   = 0               nseg    = 5              l       = 2.1e-008        xl      = 1e-009
*+          lint    = -2.5e-009       dlc     = 0              dlbin   = 0               hfin    = 3.2e-008
*+        deltaw  = 0               deltawcv= 0              sdterm  = 0               epsrsp  = 3.9
*+             nfin    = 1 toxg    = 1.8e-009
************************************************************
*                            dc                            *
************************************************************ cit     = 0               cdsc    =
*+ 0.003469        cdscd   = 0.001486        dvt0    = 0.05           dvt1    = 0.36            phin    = 0.05
*+            eta0    = 0.094           dsub    = 0.24           k1rsce  = 0               lpe0    = 0
*+               dvtshift= 0               qmfactor= 0              etaqm   = 0.54            qm0     = 2.183e-012      pqm
*+     = 0.66            u0      = 0.0237         etamob  = 4               up      = 0               ua
*+      = 1.133           eu      = 0.05           ud      = 0.0105          ucs     = 0.2672
*+          rdswmin = 0               rdsw    = 200            wr      = 1               rswmin  = 0
*+               rdwmin  = 0               rshs    = 0              rshd    = 0               vsat    = 60000
*+           deltavsat= 0.17            ksativ  = 1.592          mexp    = 2.491           ptwg    = 25              pclm
*+    = 0.01            pclmg   = 1              pdibl1  = 800             pdibl2  = 0.005704        drout
*+   = 4.97            pvag    = 200            fpitch  = 2.7e-008        rth0    = 0.15            cth0
*+    = 1.243e-006      wth0    = 2.6e-007       lcdscd  = 0               lcdscdr = 0               lrdsw
*+   = 1.3             lvsat   = 1441
************************************************************
*                         leakage                          *
************************************************************ aigc    = 0.007           bigc    =
*+ 0.0015          cigc    = 1               dlcigs  = 5e-009         dlcigd  = 5e-009          aigs    =
*+ 0.006           aigd    = 0.006           bigs    = 0.001944       bigd    = 0.001944        cigs    = 1
*+               cigd    = 1               poxedge = 1.152          agidl   = 2e-012          agisl   = 2e-012
*+          bgidl   = 1.5e+008        bgisl   = 1.5e+008       egidl   = 1.142           egisl   = 1.142
************************************************************
*                            rf                            *
************************************************************
************************************************************
*                         junction                         *
************************************************************
************************************************************
*                       capacitance                        *
************************************************************ cfs     = 0               cfd     = 0
*+               cgso    = 1.6e-010        cgdo    = 1.6e-010       cgsl    = 0               cgdl    = 0
*+               ckappas = 0.6             ckappad = 0.6            cgbo    = 0               cgbl    = 0
************************************************************
*                       temperature                        *
************************************************************ tbgasub = 0.000473        tbgbsub = 636
*+             kt1     = 0               kt1l    = 0              ute     = -1.2            utl     = 0
*+               ua1     = 0.001032        ud1     = 0              ucste   = -0.004775       at      = 0.001
*+           ptwgt   = 0.004           tmexp   = 0              prt     = 0               tgidl   = -0.007
*+          igt     = 2.5
************************************************************
*                          noise                           *
************************************************************
**)
.control
pre_osdi /home/vsduser/Documents/asap_7nm_Xschem/bsimcmg.osdi
.endc


**** end user architecture code
.end
